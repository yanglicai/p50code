# Keil uVision project MLFeng.uvprojx, settings and files
target MLFeng (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: MLFeng +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F030x8,MCU_IS_ARM
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\App\battery;..\App\driver;..\App\gui;..\App\minSystem;..\App\userApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf800
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c stm32f0xx_hal_timebase_tim.c
  group UserApp
    ../App/userApp/: app_task.c interrupt.c sysInit.c readMe.txt
  group gui
    ../App/gui/: menu.c gui.c display.c
  group bmp
    ../App/gui/bmp/: LOCK_Y16x14.c P_Y12x12.c R_Y12x12.c U_Y12x12.c UNLOCK_Y16x14.c BAT_B.c BAT_L.c BAT_R.c BAT_T.c FLASH_TECH.c BYE.c
  group homeUi
    ../App/gui/homeUi/: batUI_0_0_31x12.c Line0_50_160x5.c P_9x12.c R_140_55_12_10.c RBA_118_0_42_40.c S_11.c uiTab.c V_40_55_12_10.c W_52_54.c WARN_BACK1_45x40.c
  group smallIcon
    ../App/gui/smallIcon/: blue_Lock.c blue_P.c blue_R.c blue_U.c blue_Unlock.c green_Lock.c green_P.c green_R.c green_U.c green_Unlock.c red_Lock.c red_P.c red_R.c red_U.c red_Unlock.c
  group fonts
    ../App/gui/fonts/: fonts.c
  group Driver
    ../App/driver/: adc.c button.c keyApp.c delay.c gpio.c iic.c myTimer.c oled.c smoke.c pwm.c flash.c
  group MinSys
    ../App/minSystem/: driver_init.c systick.c myMath.c myTasks.c
  group Battery
    ../App/driver/: battery.c
    ../App/battery/: SC8913.c fastCharge_protocol.c fastCharge_driver.c fastCharge_app.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
software components: CMSIS:CORE 5.0.0
